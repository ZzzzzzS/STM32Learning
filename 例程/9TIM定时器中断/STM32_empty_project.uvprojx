# Keil uVision project STM32_empty_project.uvprojx, settings and files
target Example (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_empty_project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\App\Inc;.\Board\Inc;.\Chip\Inc;.\Lib\Inc;.\App;.\Board;.\Chip;.\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./App/Src/: main.c stm32f10x_it.c system_stm32f10x.c
    ./App/: TIM.c TIM.h
  group Board
    ./Board/Src/: systick.c Spi-OLED.c rtc.c MPU6050.c module_74hc595.c MatrixKeyboard.c led&beep.c iic.c adc.c
  group Chip
    ./Chip/Src/: core_cm3.c startup_stm32f10x_hd.s
  group Lib
    ./Lib/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
